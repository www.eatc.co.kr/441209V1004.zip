# Autodesk Inventor assembly: 조립도면
## iProperties
Created: 2014-12
Part Number: 조립도면
Document SubType Name: Assembly
Designer: elite
Author: elite
